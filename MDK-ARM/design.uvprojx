# Keil uVision project design.uvprojx, settings and files
target design (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: design +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_HAL_DRIVER,STM32F429xx
  c include: ../Inc;         ../Src;         ../TouchGFX/generated/fonts/include;         ../TouchGFX/generated/texts/include;         ../TouchGFX/generated/images/include;         ../TouchGFX/generated/gui_generated/include;         ../TouchGFX/gui/include;../middlewares/st/touchgfx/touchgfx/framework/include;         ../Drivers/STM32F4xx_HAL_Driver/Inc;         ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;         ../Middlewares/Third_Party/FreeRTOS/Source/include;         ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;         ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;         ../Drivers/BSP/Components/exc7200;         ../Drivers/BSP/Components/stmpe811;         ../Drivers/BSP/Components/ts3510;         ../Drivers/BSP/Components/ampire480272;         ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;         ../Drivers/BSP/Components/Common;         ../Drivers/CMSIS/Include;../middlewares/st/touchgfx/touchgfx/framework/include;../middlewares/st/touchgfx/touchgfx/framework/include;         ..\Mycode\Delay;         ..\Mycode\TOUCH;         ..\Mycode\UART;../middlewares/st/touchgfx/touchgfx/framework/include;../middlewares/st/touchgfx/touchgfx/framework/include;../middlewares/st/touchgfx/touchgfx/framework/include;../middlewares/st/touchgfx/touchgfx/framework/include;../middlewares/st/touchgfx/touchgfx/framework/include;../middlewares/st/touchgfx/touchgfx/framework/include
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User
    ../Src/: main.cpp freertos.c BoardConfiguration.cpp GPIO.cpp STM32F4DMA.cpp STM32F4HAL.cpp STM32F4TouchController.cpp STM32F4Instrumentation.cpp HW_Init.cpp stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dma2d.c stm32f4xx_ll_fmc.c stm32f4xx_hal_sdram.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_crc.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/TouchGFX
    ../Middlewares/ST/TouchGFX/touchgfx/os/: OSWrappers.cpp
    ../middlewares/st/touchgfx/touchgfx/lib/core/cortex_m4f/Keil/: touchgfx_core.lib
  group Application/User/TouchGFX/gui
    ../touchgfx/gui/src/common/: frontendapplication.cpp
    ../touchgfx/gui/src/model/: model.cpp
    ../touchgfx/gui/src/screen1_screen/: screen1presenter.cpp screen1view.cpp
    ../touchgfx/gui/src/screen2_screen/: screen2presenter.cpp screen2view.cpp
  group Application/User/TouchGFX/generated
    ../touchgfx/generated/fonts/src/: applicationfontprovider.cpp cachedfont.cpp font_arial_14_4bpp_0.cpp font_arial_20_4bpp_0.cpp font_arial_30_4bpp_0.cpp fontcache.cpp generatedfont.cpp kerning_arial_14_4bpp.cpp kerning_arial_20_4bpp.cpp kerning_arial_30_4bpp.cpp kerning_verdana_10_4bpp.cpp kerning_verdana_40_4bpp.cpp table_arial_14_4bpp.cpp table_arial_20_4bpp.cpp table_arial_30_4bpp.cpp table_verdana_10_4bpp.cpp table_verdana_40_4bpp.cpp
    ../touchgfx/generated/images/src/: bitmapdatabase.cpp btn.cpp btn_pressed.cpp input.cpp modal_background.cpp slider_knob_shape.cpp
    ../touchgfx/generated/images/src/__designer/: blue_buttons_round_edge_small.cpp blue_buttons_round_edge_small_pressed.cpp blue_slider_horizontal_large_indicators_slider2_round_nob.cpp blue_slider_horizontal_large_slider2_round_back.cpp blue_slider_horizontal_large_slider2_round_fill.cpp blue_slider_horizontal_medium_slider_round_edge_fill.cpp dark_buttons_round_edge_icon_button.cpp dark_buttons_round_edge_icon_button_pressed.cpp dark_buttons_round_icon_button.cpp dark_buttons_round_icon_button_pressed.cpp dark_radio_buttons_radio_round_button_active.cpp dark_radio_buttons_radio_round_button_pressed.cpp dark_slider_horizontal_medium_slider_round_edge_back.cpp dark_togglebars_toggle_re_small_button_off.cpp dark_togglebars_toggle_re_small_button_on.cpp
    ../touchgfx/generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../touchgfx/generated/texts/src/: languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../touchgfx/generated/gui_generated/src/screen1_screen/: screen1viewbase.cpp
    ../touchgfx/generated/gui_generated/src/screen2_screen/: screen2viewbase.cpp
  group Mycode
    ../Mycode/Delay/: delay.c
    ../Mycode/TOUCH/: ctiic.c ft5206.c
    ../Mycode/UART/: uart.c
software components: CMSIS:CORE 4.3.0
